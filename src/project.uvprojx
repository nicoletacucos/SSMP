# Keil uVision project project.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: Gpio.c Uart.h Gpio.h main.c Pit.c Pit.h Uart.c ClockSettings.c ClockSettings.h i2c.c i2c.h
software components: CMSIS:CORE 6.1.0, Device:Startup 2.5.0
